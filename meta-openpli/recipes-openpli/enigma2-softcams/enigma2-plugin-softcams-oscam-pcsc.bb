# oscam pcsc meta package

RDEPENDS:${PN} = "enigma2-plugin-softcams-oscam pcsc-lite libpcsclite1"
