# oscam pcsc meta package

RDEPENDS_${PN} = "enigma2-plugin-softcams-oscam-emu pcsc-lite libpcsclite1"
