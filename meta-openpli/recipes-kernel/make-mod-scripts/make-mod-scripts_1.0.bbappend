export KCFLAGS:dm8000 += "-std=gnu17"
